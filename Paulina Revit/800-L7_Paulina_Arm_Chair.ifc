Properties of the parts of a building model (IFC2X3)

# File
Description: Unknown
File name: 800 Paulina L-7
Time: 2019-04-23T09:43:07-04:00
Author: Unknown
Organization: Unknown
Written by: ST-DEVELOPER v16.7
Made in: Unknown
Authorization: OpenTools
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: OPTION: strings as raw bytes, not using required /X/ escapes
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcSite, Default Site
RefElevation: 0 in

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 in; ElevationOfTerrain: 0 in

# IfcBuildingStorey, Default Building Storey
In: Default Building
Elevation: 0 in
